#include "REGX52.H"
#include "Delay.h"
#include "MatrixLED.h"
unsigned char KunKun[]=
	{
		0x00,0x00,0x1B,0x3C,0xF8,0xFC,0x3B,0x00,0x00,0x1B,0x3C,0xFC,0xFF,0x3A,0x00,0x00,
	0x00,0x00,0x0B,0x1C,0x7C,0x7E,0x1B,0x00,0x00,0x1B,0x3C,0xFC,0xFF,0x3A,0x00,0x00,
	};
//unsigned char Animation[] = {};
void main(){
    unsigned char i,offset=0,Count=0;
    MatrixLED_Init();
    while (1)
    {
     for(i = 0;i<8;i++)
		{
			MatrixLED_ShowColumn(i,KunKun[i+offset]);}
			Count++;
			if(Count>20)
			{
				Count=0;
				offset+=8;
				if(offset>24)
					offset = 0;
			}
		}
}
